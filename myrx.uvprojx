# Keil uVision project myrx.uvprojx, settings and files
target STM32F103C8 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: myRX
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SRC
    ./src/: delay.cpp main.cpp CYRF.cpp devo.cpp TimX.cpp SEGGER_RTT.c SEGGER_RTT_printf.c
  group Include
    ./include/: codetab.h CYRF.h delay.h devo.h main.h TimX.h SEGGER_RTT.h SEGGER_RTT_Conf.h
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
